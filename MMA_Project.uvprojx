# Keil uVision project MMA_Project.uvprojx, settings and files
target MMA_Project (6140000::V6.14::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AsmTimerGPIO
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./src/: main.c i2c.c mma8451.c LED.c PeriodicTimer.c UARTCom.c Recorder.c
    ./: step_recognition.c
  group inc
    ./inc/: UARTCom.h i2c.h mma8451.h LED.h PeriodicTimer.h Recorder.h
    ./: step_recognition.h
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 5.4.0, Device:Startup 2.5.0
